# Keil uVision project smart_home.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: smart_home
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\CMSIS;..\STM32F10x_StdPeriph_Driver\inc;..\User\main;..\User\led;..\User\key;..\User\delay;..\User\uart;..\User\oled;..\User\motor;..\User\infrared;..\User\rgb;..\User\dht11;..\User\wifi;..\User\timer;..\User\relay
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ../CMSIS/: core_cm3.c startup_stm32f10x_md.s stm32f10x_it.c system_stm32f10x.c
  group STM32F10x_StdPeriph_Driver
    ../STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c misc.c stm32f10x_tim.c
  group User
    ../User/main/: main.c
    ../User/led/: led.c
    ../User/key/: key.c
    ../User/delay/: delay.c
    ../User/uart/: uart.c
    ../User/oled/: oled.c oled_dis.c
    ../User/motor/: motor.c
    ../User/infrared/: infrared.c
    ../User/rgb/: rgb.c
    ../User/dht11/: dht11.c
    ../User/wifi/: wifi.c
    ../User/timer/: timer.c
    ../User/relay/: relay.c
target Target_2 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: as above
  output: smart_home
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
